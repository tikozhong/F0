# Keil uVision project app.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: app +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\User;..\System;..\MDK5;..\output;..\STM32XX_Driver\src;..\STM32XX_Driver\inc;..\Internet\w5500;..\Internet\Application
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group user
    ../User/: main.c bsp_systick.c bsp_systick.h bsp_usart.c bsp_usart.h bsp_gpio.c bsp_gpio.h bsp_spi2.c bsp_spi2.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h types.h config.h
  group System
    ../System/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group stm32_driver
    ../STM32XX_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_bkp.c
  group W5500
    ../Internet/w5500/: md5.c md5.h socket.c socket.h w5500.c w5500.h
  group Application
    ../Internet/Application/: device.c device.h utility.c utility.h 24c16.c 24c16.h
