# Keil uVision project TCP_Server.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TCP_Server +hex
  AfterMake: fromelf.exe  --bin --output ./output/TCP_Server.bin ./output/TCP_Server.axf
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\User;.\system;.\flib\inc;.\flib\src;.\word\24c02;.\word\device;.\word\int;.\word\md5;.\word\socket;.\word\spi;.\word\ult;.\word\w5500;.\output;.\word\usart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group user
    ./User/: main.c stm32f10x_it.c stm32f10x_it.h stm32f10x_conf.h types.h config.h
  group system
    ./system/: core_cm3.c core_cm3.h startup_stm32f10x_ld.s system_stm32f10x.c
  group flib
    ./flib/src/: misc.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_fsmc.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_wwdg.c
  group word
    ./word/24c02/: 24c16.c 24c16.h
    ./word/device/: device.c device.h
    ./word/md5/: md5.c md5.h
    ./word/socket/: socket.c socket.h
    ./word/spi/: spi2.c spi2.h
    ./word/ult/: ult.c ult.h
    ./word/w5500/: w5500.c w5500.h
    ./word/usart/: usart.c usart.h
