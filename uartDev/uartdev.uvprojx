# Keil uVision project uartdev.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.3.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: uartdev
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\uartDev;..\misc;C:\Users\yong.zhong\Desktop\PIR\FW\FW-MBPIRTEST-02\Drivers\STM32F0xx_HAL_Driver\Inc;C:\Users\yong.zhong\Desktop\PIR\FW\FW-MBPIRTEST-02\Drivers\STM32F0xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group uartDev
    ./: uartDev.c
    ../misc/: misc.c
